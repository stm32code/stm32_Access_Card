# Keil uVision project XIAOCHE.uvprojx, settings and files
target XIAOCHE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XIAOCHE +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\TIMER;..\HARDWARE\UART;..\HARDWARE\LCD1602;..\HARDWARE\RC522;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\PASSWORD;..\HARDWARE\STMFLASH;..\HARDWARE\AS608;..\HARDWARE\USART3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: system_stm32f10x.c MAIN.c
  group HARDWARE
    ../HARDWARE/TIMER/: TIMER.c
    ../HARDWARE/UART/: buletooth.c
    ../HARDWARE/LCD1602/: LCD1602.C
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/RC522/: rc522.c
    ../HARDWARE/SPI/: SPI.C
    ../HARDWARE/PASSWORD/: PASSKEY.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/USART3/: USART3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_flash.c
